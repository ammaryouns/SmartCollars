# Keil uVision project Cowlar Node-v10-L452.uvprojx, settings and files
target Cowlar Node-v10-L452 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Cowlar Node-v10-L452 +hex
  AfterMake: "$KARM\ARMCC\bin\fromelf.exe" --bin --output="output"  ".\Project-Objects\\Cowlar Node-v10-L452.axf"
  AfterMake: ".\addCRC.exe" "output\\HEADER_REGION.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32L452xx, ARM_MATH_CM4,STM32L452xx
  c include: ../Inc;         ../Drivers/STM32L4xx_HAL_Driver/Inc;         ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;         ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;         ..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ..\Drivers\CMSIS\Include;         ..\Drivers\BSP\Cowlar-node-v8;         ..\Drivers\BSP\Components\Common;         ..\ThirdParty\Firmware;         ..\ThirdParty;         ..\Middlewares\NeuralNetwork;         ..\ThirdParty\COWLAR DSP LIB;         ..\ThirdParty\IPC;         ..\ThirdParty\FileSystem\ff13\source;         ..\Drivers\SDcard;         ..\ThirdParty\INA219;         ..\Drivers\BSP\Components;         ..\Drivers\BSP\Components\sx1262xlib;         ..\Middlewares\LoRaDemoApplication;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;         ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;         ../Drivers/CMSIS/Include;         ..\ThirdParty\LoRaWAN;         ..\Drivers\BSP\Components\sx1262xlib\sx126x;         ..\Drivers\BSP\Components\sx1262xlib\board;         ..\Drivers\BSP\NFCv10;         ..\Drivers\BSP\Components\st25dv
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Application/MDK-ARM
    ./: startup_stm32l452xx.s
  group Application/User
    ../Src/: Device_Params.c main.c gpio.c adc.c crc.c dma.c freertos.c i2c.c iwdg.c usart.c rtc.c spi.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP
    ../Drivers/BSP/Cowlar-node-v8/: SensorTile_accelero.c SensorTile_gyro.c Cowlar-node-v8.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_fifo.c LSM6DSM_ACC_GYRO_driver_HL.c
  group Firmware
    ../ThirdParty/Firmware/: FwFile.c mFile.c
  group Middlewares
    ../ThirdParty/: crc32.c mIWDG.c mRTC.c log.c mFLASH.c mQueue.c mQueue_List.c SensorDefs.c mBuffer.c DEBUG_UART.c
  group Middlewares/APP
    ../Src/: Cowlar_app_v8.c
  group Middlewares/DSP
    ../ThirdParty/COWLAR DSP LIB/: arm_abs_add_f32.c arm_resultant_vector_f32.c MPU_Features.c MPU_Filter.c
  group Midlewares/FatFs
    ../ThirdParty/FileSystem/ff13/source/: app1.c diskio.c ff.c ffsystem.c ffunicode.c
  group Drivers/SDcard
    ../Drivers/SDcard/: SDcardSPI.c
  group Drivers/INA219
    ../ThirdParty/INA219/: INA219.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group ThirdParty/LoRa
    ../Drivers/BSP/Components/sx1262xlib/: LoRa.c
    ../Drivers/BSP/Components/sx1262xlib/sx126x/: sx126x.c radio.c
    ../ThirdParty/LoRaWAN/: MAC.c MAC_Application.c MAC_Node_FirmwareApp.c
    ../Drivers/BSP/Components/sx1262xlib/board/: sx126x-board.c
  group Drivers/BSP/NFC
    ../Drivers/BSP/NFCv10/: nfc04a1.c nfc04a1_nfctag.c NFC_application.c
  group Drivers/BSP/st25dv
    ../Drivers/BSP/Components/st25dv/: st25dv.c
    ../Drivers/BSP/NFCv10/: TagType5.c
target Cowlar Node-v10-L452_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: Cowlar Node-v10-L452 +hex
  AfterMake: as above
  AfterMake: ".\addCRC.exe" "output\\HEADER_REGION.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32L452xx, ARM_MATH_CM4,STM32L452xx
  c include: as above
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\Cowlar Node-v10-L452.sct
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
